# Keil uVision project CNC.uvprojx, settings and files
target CNC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CNC +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\;..\Driver;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\user;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\user\FatFs;..\user\USB\inc;..\user\FreeModbus\modbus\include;..\user\FreeModbus\modbus\rtu;..\user\FreeModbus\port;..\GCode;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Driver
    ../Driver/: bsp.c stm32f10x_it.c static_init.c BKP_Init.c I2CEEPROM.c nvic_init.c printf_init.c spi_flash.c USART1_init.c USART2_init.c GPIO_Init.c SPI2_Init.c
  group USER
    ../GCode/: cnc.c
    ../user/: main.c
  group FatFS
    ../user/FatFs/: fatfs_app.c ff.c
    ../user/FatFs/Disk IO Interface/: diskio.c
    ../user/FatFs/option/: ccsbcs.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STM32_USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ../user/USB/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c USB_config.c
  group G Code
    ../GCode/: coolant_control.c eepromcnc.c gcode.c limits.c motion_control.c nuts_bolts.c planner.c protocol.c report.c settings.c stepper.c print.c spindle_control.c
